# Keil uVision project TOUCH.uvprojx, settings and files
target TOUCH (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\CORE;..\OBJ;..\USER;..\USMART;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\TOUCH;..\HARDWARE\lvgl;..\HARDWARE\lvgl\lvgl\tests\lv_test_widgets;..\HARDWARE\lvgl\lvgl\src\lv_widgets;..\HARDWARE\lvgl\lvgl\examples\porting;..\HARDWARE\lvgl\lvgl\src;..\HARDWARE\lvgl\lvgl\src\lv_widgets;..\HARDWARE\lvgl\lvgl_app\lv_examples\src\lv_ex_widgets;..\HARDWARE\lvgl\lvgl_app\lv_examples\src\lv_demo_widgets;..\HARDWARE\TIMER;..\HARDWARE\lvgl\lvgl\src\lv_hal;..\HARDWARE\lvgl\lvgl_app\lv_examples\src\lv_ex_widgets\lv_ex_calendar;..\HARDWARE\lvgl\lvgl\examples\porting;..\HARDWARE\lvgl\generated\images;..\HARDWARE\lvgl\generated\guider_fonts;..\HARDWARE\lvgl\generated\guider_customer_fonts;..\HARDWARE\lvgl\generated;..\HARDWARE\lvgl\lvgl\src\lv_font;..\HARDWARE\lvgl\lvgl\examples\porting
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c stm32f4xx_hal_msp.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h startup_stm32f407xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/TOUCH/: ctiic.c ft5206.c gt9147.c ott2001a.c touch.c
    ../HARDWARE/TIMER/: timer.c
  group USMART
    ../USMART/: usmart.c usmart_str.c usmart_config.c
  group README
    ../: readme.txt
  group gui_lvglSRC
    ../HARDWARE/lvgl/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ../HARDWARE/lvgl/lvgl/src/lv_draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../HARDWARE/lvgl/lvgl/src/lv_font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../HARDWARE/lvgl/lvgl/src/lv_gpu/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c
    ../HARDWARE/lvgl/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../HARDWARE/lvgl/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_debug.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_task.c lv_templ.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../HARDWARE/lvgl/lvgl/src/lv_themes/: lv_theme.c lv_theme_empty.c lv_theme_material.c lv_theme_mono.c lv_theme_template.c
    ../HARDWARE/lvgl/lvgl/src/lv_widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_calendar.c lv_canvas.c lv_chart.c lv_checkbox.c lv_cont.c lv_cpicker.c lv_dropdown.c lv_gauge.c lv_img.c lv_imgbtn.c lv_keyboard.c lv_label.c lv_led.c lv_line.c lv_linemeter.c lv_list.c lv_msgbox.c lv_objmask.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_spinbox.c lv_spinner.c lv_switch.c lv_table.c lv_tabview.c lv_textarea.c lv_tileview.c lv_win.c
  group gui_lvglAPP
    ../HARDWARE/lvgl/lvgl_app/lv_examples/src/lv_demo_widgets/: lv_demo_widgets.c
    ../HARDWARE/lvgl/lvgl_app/lv_examples/src/lv_ex_widgets/lv_ex_calendar/: lv_ex_calendar_1.c
    ../HARDWARE/lvgl/lvgl_app/lv_examples/src/lv_demo_keypad_encoder/: lv_demo_keypad_encoder.c
    ../HARDWARE/lvgl/lvgl_app/lv_examples/src/lv_ex_widgets/lv_ex_slider/: lv_ex_slider_1.c lv_ex_slider_2.c
  group gui_lvglPort
    ../HARDWARE/lvgl/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
  group generated
    ../HARDWARE/lvgl/generated/: events_init.c gui_guider.c setup_scr_screen.c
    ../HARDWARE/lvgl/generated/guider_fonts/: lv_font_simsun_12.c
  group clock
    ../HARDWARE/lvgl/clock/: anlog.c hour.c minute.c second.c watch_bg.c
