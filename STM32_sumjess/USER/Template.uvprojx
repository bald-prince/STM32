# Keil uVision project Template.uvprojx, settings and files
target sumjessTemplate (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\USER;..\STM32F10x_FWLIB\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HAREWARE\LED;..\HAREWARE\KEY;..\HAREWARE\WDG;..\HAREWARE\EXTI;..\HAREWARE\TIMER;..\HAREWARE\PWM;..\HAREWARE\OLED;..\USMART;..\HAREWARE\LCD\ZLCD;..\HAREWARE\REMOTE;..\HAREWARE\IIC;..\HAREWARE\SPI;..\HAREWARE\UltrasonicWave;..\HAREWARE\MPU6050;..\HAREWARE\MPU6050\eMPL;..\HAREWARE\bujin;..\HAREWARE\HC05;..\HAREWARE\BEEP;..\HAREWARE\DAC;..\HAREWARE\DMA;..\HAREWARE\cs;..\HAREWARE\malloc;..\HAREWARE\MPU6050;..\HAREWARE\key44;..\HAREWARE;..\HAREWARE\USART3;..\HAREWARE\USART2;..\HAREWARE\RTC;..\HAREWARE\WKUP;..\Food_robot\track;..\Food_robot\MOTOR;..\HAREWARE\DHT11;..\Food_robot\food_oled
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group sum_AD
    ../HAREWARE/DAC/: dac.c
    ../HAREWARE/ADC/: adc.c
  group FoodDelivered-Robot
    ../Food_robot/track/: sumjess_track.c
    ../Food_robot/MOTOR/: sumjess_track_motor.c
    ../Food_robot/food_oled/: food_OLED.c
  group sum_USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group sum_CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group sum_FWLIB
    ../STM32F10x_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group sum_SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group sum_display
    ../HAREWARE/OLED/: sumjess_oled.c
    ../HAREWARE/LCD/ZLCD/: lcd.c
  group sum_electrical
    ../HAREWARE/bujin/: sumjess_stepper_motor.c
    ../HAREWARE/: sumjess_L298N.c
  group sum_USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group sum_MPU6050
    ../HAREWARE/MPU6050/: mpuiic.c sumjess_mpu6050.c sumjess_my_pitch.c
    ../HAREWARE/MPU6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group sum_HAREWARE
    ../HAREWARE/WDG/: wdg.c
    ../HAREWARE/TIMER/: timer.c
    ../HAREWARE/RTC/: rtc.c
    ../HAREWARE/PWM/: sumjess_pwm.c
    ../HAREWARE/EXTI/: sumjess_exti.c
    ../HAREWARE/WKUP/: wkup.c
    ../HAREWARE/DHT11/: dht11.c
  group sum_communicate
    ../HAREWARE/24CXX/: 24cxx.c
    ../HAREWARE/DMA/: dma.c
    ../HAREWARE/IIC/: myiic.c
    ../HAREWARE/SPI/: spi.c
    ../HAREWARE/USART2/: sumjess_usart2.c
  group sum_Other modules
    ../HAREWARE/REMOTE/: remote.c
    ../HAREWARE/BEEP/: beep.c
    ../HAREWARE/KEY/: key.c
    ../HAREWARE/LED/: LEDji.c LED.c
    ../HAREWARE/UltrasonicWave/: sumjess_UltrasonicWave.c
    ../HAREWARE/key44/: sumjess_key4x4.c
    ../HAREWARE/malloc/: sumjess_malloc.c
  group sum_explain
    ../explain/: ex-beep.c ex-gpio.c ex-key.c ex-usart.c ex-usart2.c ex-lcd.c ex-exti.c ex-wdg.c ex-timer.c ex-pwm.c ex-oled.c ex-usmart.c ex-wkup.c ex-RTC.c ex-adc.c ex-dac.c ex-mpu6050.c ex-remote.c ex-dma.c ex-sizhongtimer.c ex-UltrasonicWave.c ex-dht11.c
